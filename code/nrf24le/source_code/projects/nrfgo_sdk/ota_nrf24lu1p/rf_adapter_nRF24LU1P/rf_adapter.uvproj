# Keil uVision project rf_adapter.uvproj, settings and files
target USB_Dongle (MCS-51)
  device: nRFLU1P-F32 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\hal;..\..\..\..\hal\nrf24l01p;..\..\..\..\hal\nrf24lu1p;..\..\..\..\compiler\c51;..\..\..\..\compiler\common;..\common
  link misc: REMOVEUNUSED
  group SRC
    ./: STARTUP.A51 main.c
  group USB
    ./: usb_desc.c
  group HAL
    ../../../../hal/nrf24lu1p/: hal_flash.c hal_usb.c hal_usb_hid.c hal_nrf_hw.c hal_spi.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../hal/: hal_delay.c
