# Keil uVision project uart_nrf24le1.uvproj, settings and files
target uart_nrf24le1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: uart_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\hal\nrf24le1;..\..\..\..\compiler\c51;..\..\..\..\compiler\common
  group application
    ../src/: main.c application.c
  group hal
    ../../../../hal/nrf24le1/: hal_clk.c hal_uart.c
  group utility
    ../src/: utility.c hal_types.h
