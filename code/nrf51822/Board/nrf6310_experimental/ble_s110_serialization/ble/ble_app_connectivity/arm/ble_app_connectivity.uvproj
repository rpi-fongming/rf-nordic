# Keil uVision project ble_app_connectivity.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_connectivity +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51, BOARD_NRF6310, DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\Include\ble\rpc;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x00014000 size 0x0002B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group Startup Code
    ./../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_stack_handler.c ble_debug_assert_handler.c ble_error_log.c ble_flash.c
    ../../../Source/app_common/: rpc_transport.c app_transport_uart.c
    ../../../Source/ble/rpc/: ble_rpc_cmd_decoder.c ble_rpc_event_encoder.c
    ../../../../../../Source/app_common/: app_gpiote.c app_scheduler.c app_uart.c app_fifo.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_connectivity +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51, BOARD_NRF6310, DEBUG_NRF_USER
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00014000 size 0x0000B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
