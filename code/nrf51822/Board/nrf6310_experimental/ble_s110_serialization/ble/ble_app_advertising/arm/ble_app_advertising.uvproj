# Keil uVision project ble_app_advertising.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_advertising +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\Include\ble\rpc;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group Startup Code
    ./../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_stack_handler.c ble_debug_assert_handler.c ble_flash.c ble_error_log.c
    ../../../Source/app_common/: app_transport_uart.c rpc_transport.c
    ../../../../../../Source/app_common/: app_uart.c app_fifo.c app_gpiote.c
    ../../../Source/ble/rpc/: ble_rpc_cmd_encoder.c ble_rpc_event_decoder.c
    ../../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../source/ble/rpc/: ble_rpc_sd_stub.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_advertising +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
