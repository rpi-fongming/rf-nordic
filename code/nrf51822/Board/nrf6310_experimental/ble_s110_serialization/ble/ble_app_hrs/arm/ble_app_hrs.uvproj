# Keil uVision project ble_app_hrs.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\ble\softdevice;..\..\..\include\app_common;..\..\..\include\ble\rpc
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group Startup Code
    ../../../../../../Source/templates/: system_nrf51.c
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_hrs.c ble_dis.c ble_bas.c
  group Libraries
    ../../../source/app_common/: app_transport_uart.c rpc_transport.c
    ../../../source/ble/rpc/: ble_rpc_cmd_encoder.c ble_rpc_event_decoder.c ble_rpc_sd_stub.c
    ../../../../../../Source/app_common/: app_uart.c app_timer.c app_gpiote.c app_scheduler.c app_fifo.c
    ../../../../../../Source/ble/: ble_bondmngr.c ble_conn_params.c ble_debug_assert_handler.c ble_radio_notification.c ble_sensorsim.c ble_stack_handler.c ble_advdata.c ble_error_log.c ble_flash.c
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../../Source/nrf_delay/: nrf_delay.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_hrs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
