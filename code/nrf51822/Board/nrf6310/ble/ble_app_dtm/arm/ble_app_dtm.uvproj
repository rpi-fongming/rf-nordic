# Keil uVision project ble_app_dtm.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_dtm +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\ble;..\..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x00014000 size 0x0002B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  link misc: --remove
  group Startup Code
    ../../../../../Source/templates/: system_nrf51.c
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c
  group Libraries
    ../../../../../Source/ble/: ble_dtm.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_dtm +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\ble;..\..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x00014000 size 0x0000B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  link misc: --remove
